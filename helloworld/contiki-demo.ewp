# IAR project contiki-demo.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: NETSTACK_CONF_WITH_IPV6=1; BUTTON_SENSOR_CONF_ON=0; VIZTOOL_CONF_ON=0; ADC_SENSOR_CONF_ON=0; NETSTACK_CONF_RDC=contikimac_driver; NETSTACK_CONF_FRAMER=contikimac_framer
  ICC8051.CCDiagSuppress: Pa082
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\contiki\core; ..\contiki\core\net; ..\contiki\core\sys; ..\contiki\core\lib; ..\contiki\cpu\cc253x; ..\contiki\platform\cc2530dk; ..\User
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: Linker\f8w2530.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  General.RTConfigPath: xxx.h
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group contiki/core/dev
    ../contiki/core/dev/: battery-sensor.h button-sensor.h eeprom.h leds.c leds.h nullradio.c nullradio.h radio-sensor.h radio.h rom.h serial-line.c serial-line.h slip.c slip.h spi.h watchdog.h xmem.h
  group contiki/core/lib
    ../contiki/core/lib/: aes-128.c aes-128.h assert.c assert.h crc16.c crc16.h gcr.c gcr.h ifft.c ifft.h list.c list.h me.c me.h me_tabs.c me_tabs.h memb.c memb.h mmem.c mmem.h petsciiconv.c petsciiconv.h print-stats.c print-stats.h random.c random.h ringbuf.c ringbuf.h sensors.c sensors.h settings.c settings.h trickle-timer.c trickle-timer.h
  group contiki/core/lib/strncasecmp
    ../contiki/core/lib/strncasecmp/: strncasecmp.c
  group contiki/core/net
    ../contiki/core/net/: linkaddr.c linkaddr.h nbr-table.c nbr-table.h netstack.c netstack.h packetbuf.c packetbuf.h queuebuf.c queuebuf.h
  group contiki/core/net/ip
    ../contiki/core/net/ip/: dhcpc.c dhcpc.h psock.c psock.h resolv.c resolv.h simple-udp.c simple-udp.h slipdev.c slipdev.h tcp-socket.c tcp-socket.h tcpip.c tcpip.h udp-socket.c udp-socket.h uip-debug.c uip-debug.h uip-packetqueue.c uip-packetqueue.h uip-split.c uip-split.h uip-udp-packet.c uip-udp-packet.h uip.h uip_arch.h uiplib.c uiplib.h uipopt.h
  group contiki/core/net/ip64-addr
    ../contiki/core/net/ip64-addr/: ip64-addr.c ip64-addr.h
  group contiki/core/net/ipv6
    ../contiki/core/net/ipv6/: sicslowpan.c sicslowpan.h uip-ds6-nbr.c uip-ds6-nbr.h uip-ds6-route.c uip-ds6-route.h uip-ds6.c uip-ds6.h uip-icmp6.c uip-icmp6.h uip-nd6.c uip-nd6.h uip6.c
  group contiki/core/net/ipv6/multicast
    ../contiki/core/net/ipv6/multicast/: roll-tm.c roll-tm.h smrf.c smrf.h uip-mcast6-engines.h uip-mcast6-route.c uip-mcast6-route.h uip-mcast6-stats.c uip-mcast6-stats.h uip-mcast6.h
  group contiki/core/net/llsec
    ../contiki/core/net/llsec/: anti-replay.c anti-replay.h ccm-star.c ccm-star.h llsec.h llsec802154.h nullsec.c nullsec.h
  group contiki/core/net/llsec/noncoresec
    ../contiki/core/net/llsec/noncoresec/: noncoresec.c noncoresec.h
  group contiki/core/net/mac
    ../contiki/core/net/mac/: csma.c csma.h frame802154.c frame802154.h framer-802154.c framer-802154.h framer-nullmac.c framer-nullmac.h framer.c framer.h mac-sequence.c mac-sequence.h mac.c mac.h nullmac.c nullmac.h nullrdc-noframer.c nullrdc-noframer.h nullrdc.c nullrdc.h phase.c phase.h rdc.h
  group contiki/core/net/mac/contikimac
    ../contiki/core/net/mac/contikimac/: contikimac-framer.c contikimac-framer.h contikimac.c contikimac.h
  group contiki/core/net/mac/cxmac
    ../contiki/core/net/mac/cxmac/: cxmac.c cxmac.h
  group contiki/core/net/mac/sicslowmac
    ../contiki/core/net/mac/sicslowmac/: sicslowmac.c sicslowmac.h
  group contiki/core/net/rpl
    ../contiki/core/net/rpl/: rpl-conf.h rpl-dag.c rpl-ext-header.c rpl-icmp6.c rpl-mrhof.c rpl-of0.c rpl-private.h rpl-timers.c rpl.c rpl.h
  group contiki/core/sys
    ../contiki/core/sys/: arg.c arg.h autostart.c autostart.h cc.h clock.h compower.c compower.h ctimer.c ctimer.h dsc.h energest.c energest.h etimer.c etimer.h lc-addrlabels.h lc-switch.h lc.h loader.h log.h mt.c mt.h node-id.h process.c process.h procinit.c procinit.h pt-sem.h pt.h rtimer.c rtimer.h stimer.c stimer.h subprocess.h timer.c timer.h
  group contiki/cpu/cc253x
    ../contiki/cpu/cc253x/: 8051def.h cc253x.h mtarch.h rtimer-arch.c rtimer-arch.h sfr-bits.h soc.c soc.h stack.c stack.h
  group contiki/cpu/cc253x/dev
    ../contiki/cpu/cc253x/dev/: cc2530-rf.c cc2530-rf.h clock-isr.h clock.c dma.c dma.h dma_intr.c lpm.h port.h port2-intr.c port2.c port2.h random.c uart-intr.c uart.h uart0.c uart0.h uart1.c uart1.h watchdog.c
  group contiki/platform/cc2530dk
    ../contiki/platform/cc2530dk/: contiki-conf.h contiki-main.c debug.c debug.h models.h putchar.c uip-debug.c viztool.c
  group contiki/platform/cc2530dk/dev
    ../contiki/platform/cc2530dk/dev/: io-arch.h leds-arch.c leds-arch.h
  group User
    User/: hello-world.c
